# Keil uVision project STM32F411VET6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411VET6
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:Startup 2.6.3
